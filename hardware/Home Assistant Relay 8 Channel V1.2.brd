# Repository Makerfabs/Home-Assistant-Relay-8-Channel

File README.md:

# Makerfabs Home Assistant Relay 8 Channel

## Intruduce
[Product Link](https://www.makerfabs.com/8-channel-relay-for-home-assistant.html)

[Wiki Link](https://wiki.makerfabs.com/How-to-use-Home-Assistant-Relay-8-Channel.html)

## EAGLE design hardware/Home Assistant Relay 8 Channel V1.2.brd

Notes on the sheet:
ESP32
DC 3.3V
ETHERNET
SWITCH
RELAY
Interface
Led
WIFI&BLE
Block Diagram
Home Assistant Relay 8 Channel

Parts:
C1, C9, C10, C11, C12, C13, C15, C16, C19, C20, C21, C23, C24: 100nF; C0603
C2, C17, C18, C22: 10uF; C0603
C3, C6, C7: 220uF; SMD-6.3*5
C4, C5, C8, C14: 1uF; C0603
D1: SS56; DO-214
D2: SMAJ24CA; DO-214
D3: SS34; DO-214AC
FLASH: 7.62X3.56-90D; 2P-7.62X3.56-90D
J1: 5.5x2.1; POWER_JACK_SMD
J3: HR911105A
J4, J5, J6, J7, J8, J9, J10, J11: EDG-5.08-3P-180°; EDG5.08MM-3P-180°
L1: 68µH/±30%/2A; CR54
L2: 100R/500mA; R0603
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9: 0603-G; LED0603
Q11, Q12: S8050; SOT23
R1, R2, R3, R4, R5, R6, R7, R8: 2K; R0603
R9, R10: 510R; R0603
R11, R12, R22, R23, R24, R27, R29, R30, R31, R32: 10K; R0603
R13: 12.1K; R0603
R14, R16, R17, R18: 49R9; R0603
R15, R19, R25, R26, R28: 4.7K; R0603
R20, R21: 5.1K; R0603
RESET: 7.62X3.56-90D; 2P-7.62X3.56-90D
S1, S2, S3, S4, S5, S6, S7, S8: JQC-5P-12V; JQC-5P-5V
S9: 219-08; CTS-219-08
U1: ESP-WROOM-32
U2: XL1509; SOP8
U3: REG1117; SOT223
U4: ULN2803; MSOP18
U5, U7: 74HCT14; SO14
U6: CH340K; ESOP-10-EP-150MIL
U8: LAN8720A; QFN24-4X4
USB-TTL: USB_C5; USB-C-16P-5

Connections:
+3V3: C2.1, C8.1, C9.1, C13.1, C14.1, C15.1, C16.1, L2.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R22.2, R23.2, R24.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, U1.2 (3V3), U3.2 (VOUT), U6.7 (VCC), U6.10 (V3)
+5V: C5.1, C6.+, C7.+, C11.1, C12.1, C17.1, L1.P$2 (2), U2.3 (FB), U3.3 (VIN), U5.14 (VCC), U7.14 (VCC), USB-TTL.VBUS1 (VBUS), USB-TTL.VBUS2 (VBUS)
+12V: C3.+, C4.1, C10.1, D1.C, R19.1, S1.1, S2.1, S3.1, S4.1, S5.1, S6.1, S7.1, S8.1, U2.1 (VIN), U4.10 (COM)
CLK_NET: U1.28 (IO17), U8.5 (XTAL1)
COM1: J4.2, S1.2
COM2: J5.2, S2.2
COM3: J6.2, S3.2
COM4: J7.2, S4.2
COM5: J8.2, S5.2
COM6: J9.2, S6.2
COM7: J10.2, S7.2
COM8: J11.2, S8.2
D+: U6.1 (UD+), USB-TTL.A6 (D+), USB-TTL.B6 (D+)
D-: U6.2 (UD-), USB-TTL.A7 (D-), USB-TTL.B7 (D-)
DTR: Q11.2 (E), R25.1, U6.4 (DTR#)
EMAC_MDC: U1.37 (IO23), U8.13 (MDC)
EMAC_MDIO: U1.30 (IO18), U8.12 (MDIO)
EMAC_RXD0: U1.10 (IO25), U8.8 (RXD0)
EMAC_RXD1: U1.11 (IO26), U8.7 (RXD1)
EMAC_RXDV: U1.12 (IO27), U8.11 (CRS_DV)
EMAC_TXD0: U1.31 (IO19), U8.17 (TXD0)
EMAC_TXD1: U1.36 (IO22), U8.18 (TXD1)
EMAC_TXEN: U1.33 (IO21), U8.16 (TXEN)
GND: C1.2, C2.2, C3.-, C4.2, C5.2, C6.-, C7.-, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, D2.A, D3.A, FLASH.P$2 (2), J1.GND (GNDBREAK), J1.P$4 (GND), J3.10, J3.A, J3.B, LED9.C, R11.1, R13.1, R20.1, R21.1, RESET.P$2 (2), S9.1, S9.2, S9.3, S9.4, S9.5, S9.6, S9.7, S9.8, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.GND, U2.4 (EN), U2.5 (GND4), U2.6 (GND3), U2.7 (GND2), U2.8 (GND), U3.1 (GND), U4.9 (GND), U5.7 (GND), U5.11 (A5), U5.13 (A6), U6.3 (GND), U6.EP, U7.7 (GND), U7.11 (A5), U7.13 (A6), U8.EXP (VSS), USB-TTL.GND, USB-TTL.GND2 (GND)
IO0: FLASH.P$1 (1), Q11.3 (C), R28.1, U1.25 (IO0)
LED_G: R10.1, R11.2, U8.3 (LED1)
LED_Y: R9.1, U8.2 (LED2)
unnamed: D3.C, L1.P$1 (1), U2.2 (OUT)
unnamed: LED1.A, R1.2
unnamed: LED2.A, R2.2
unnamed: LED3.A, R3.2
unnamed: LED4.A, R4.2
unnamed: LED5.A, R5.2
unnamed: Q12.1 (B), R25.2
unnamed: Q11.1 (B), R15.2
unnamed: LED6.A, R6.2
unnamed: LED7.A, R7.2
unnamed: LED8.A, R8.2
unnamed: J3.11, R9.2
unnamed: J3.9, R10.2
unnamed: R13.2, U8.24 (RBIAS)
unnamed: C24.1, R12.1, U8.15 (NRST)
unnamed: D1.A, D2.C, J1.VIN0 (PWR)
unnamed: LED9.A, R19.2
unnamed: R21.2, USB-TTL.A5 (CC1)
unnamed: R20.2, USB-TTL.B5 (CC2)
NC1: J4.3, S1.4
NC2: J5.3, S2.4
NC3: J6.3, S3.4
NC4: J7.3, S4.4
NC5: J8.3, S5.4
NC6: J9.3, S6.4
NC7: J10.3, S7.4
NC8: J11.3, S8.4
NO1: J4.1, S1.5
NO2: J5.1, S2.5
NO3: J6.1, S3.5
NO4: J7.1, S4.5
NO5: J8.1, S5.5
NO6: J9.1, S6.5
NO7: J10.1, S7.5
NO8: J11.1, S8.5
O1: U4.1 (IN1), U5.2 (1Y)
O2: U4.2 (IN2), U5.4 (2Y)
O3: U4.3 (IN3), U5.6 (3Y)
O4: U4.4 (IN4), U5.8 (4Y)
O5: U4.5 (IN5), U7.2 (1Y)
O6: U4.6 (IN6), U7.4 (2Y)
O7: U4.7 (IN7), U7.6 (3Y)
O8: U4.8 (IN8), U7.8 (4Y)
RESET: C1.1, Q12.3 (C), R26.1, RESET.P$1 (1), U1.3 (EN)
REY1: S1.3, U4.18 (OUT1)
REY2: S2.3, U4.17 (OUT2)
REY3: S3.3, U4.16 (OUT3)
REY4: S4.3, U4.15 (OUT4)
REY5: S5.3, U4.14 (OUT5)
REY6: S6.3, U4.13 (OUT6)
REY7: S7.3, U4.12 (OUT7)
REY8: S8.3, U4.11 (OUT8)
RTS: Q12.2 (E), R15.1, U6.6 (RTS#)
RXD: U1.34 (RXD0), U6.8 (TXD)
RX_N: J3.6 (RD-), R18.2, U8.22 (RXN)
RX_P: J3.3 (RD+), R17.2, U8.23 (RXP)
T1: LED1.C, R22.1, S9.16, U1.8 (IO32), U5.1 (A1)
T2: LED2.C, R23.1, S9.15, U1.9 (IO33), U5.3 (A2)
T3: LED3.C, R24.1, S9.14, U1.13 (IO14), U5.5 (A3)
T4: LED4.C, R27.1, S9.13, U1.16 (IO13), U5.9 (A4)
T5: LED5.C, R29.1, S9.12, U1.23 (IO15), U7.1 (A1)
T6: LED6.C, R30.1, S9.11, U1.26 (IO4), U7.3 (A2)
T7: LED7.C, R31.1, S9.10, U1.27 (IO16), U7.5 (A3)
T8: LED8.C, R32.1, S9.9, U1.29 (IO5), U7.9 (A4)
TXD: U1.35 (TXD0), U6.9 (RXD)
TX_N: J3.2 (TD-), R16.2, U8.20 (TXN)
TX_P: J3.1 (TD+), R14.2, U8.21 (TXP)
VCC: C18.1, C19.1, C20.1, C21.1, J3.4, J3.5, J3.12, L2.2, R12.2, R14.1, R16.1, R17.1, R18.1, U8.1 (VDD2A), U8.9 (VDDIO), U8.19 (ADD1A)
VDDCR: C22.1, C23.1, U8.6 (VDDCR)

Notes on the sheet:
Home Assistant Relay 8 Channel
Power DC-DC
MCU
IO34~IO39 input only
key flash
USB to UART
USB TO SERIAL CONVERTER
Version
Date
Designer
Home Assistant Relay 8 Channel V1.2
20230721
Peter
OUTPUT
ETHERNET
USB
USB Type C
LED-RELAY
Manual
继电器与连接器连接部分开窗露铜拖锡处理，增大负载能力和加强散热。

Board: 2 copper layers, 122.0 x 87.0 mm, 104 parts (0 on the bottom side), 96 nets.

Other parts of the board:
U$1, U$2: MAKERFABS_0.3

## Commit log

2023-07-20 Edit readme
2023-07-21 Add hardware
2025-09-27 update README.md&yaml

Notices in the files:
parts and their libraries:
SparkFun-Coils: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
